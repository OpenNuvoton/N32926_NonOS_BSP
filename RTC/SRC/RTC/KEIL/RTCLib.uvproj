# Keil uVision project RTCLib.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_RTClib (library)
  AfterMake: Release.bat
  c flags: Optim=1 wLevel=2
  c define: __LIBRARY__
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: RTC.c
