# Keil uVision project AMPIRE_800x480_18B.uvproj, settings and files
target W55FA92_AMPIRE_800x480_18B (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_AMPIRE_800x480_18B (library)
  AfterMake: .\W55FA92_AMPIRE_800x480_18B.bat
  c flags: Optim=1 wLevel=2
  c define: __HAVE_AMPIRE_800x480_18B__
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: W55FA92_VPOST.C W55FA92_VPOST_Driver.c W55FA92_VPOST_AMPIRE_800x480_18B.c
