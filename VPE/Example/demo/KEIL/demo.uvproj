# Keil uVision project demo.uvproj, settings and files
target VPE_LCM_QVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LCM_320X240
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../: standalone.c wb_init.s main_vpe.c vpe_pattern.c
    ../../../Lib/: W55FA92_VPE.lib
    ../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
