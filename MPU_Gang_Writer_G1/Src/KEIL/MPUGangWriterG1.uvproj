# Keil uVision project MPUGangWriterG1.uvproj, settings and files
target QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: MPUGangWriterG1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: ..\..\..\SYSLIB\Lib;..\..\..\Font\Lib;..\..\..\GNAND\Lib;..\..\..\GPIO\lib;..\..\..\NVTFAT\lib;..\..\..\SIC\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../: DrawFont.c nvtNandDrv.c ProcessIni.c ProcessOptionalIni.c standalone.c Writer.c wb_init.s InterfaceCtl.c
    ../../../Font/Lib/: W55FA92_Font_QVGA.lib
    ../../../GNAND/Lib/: w55fa92_GNAND.lib
    ../../../GPIO/lib/: w55fa92_gpio.lib
    ../../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
