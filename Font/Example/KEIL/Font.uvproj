# Keil uVision project Font.uvproj, settings and files
target QVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Font_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: ..\..\..\SYSLIB\Lib;..\..\Lib;..\..\..\VPOST\Lib;..\..\..\SIC\Lib
  asm define: N9H26K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Src
    ../: DrawFont.c standalone.c Font_demo.c wb_init.s
  group Lib
    ../../Lib/: W55FA92_Font_QVGA.lib W55FA92_Font_VGA.lib W55FA92_Font_WQVGA.lib W55FA92_Font_WVGA.lib
    ../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../GNAND/Lib/: W55FA92_GNAND.lib
    ../../../NVTFAT/Lib/: W55FA92_NVTFAT.lib
    ../../../SYSLIB/Lib/: W55FA92_SYSLib.lib
    ../../../GPIO/Lib/: W55FA92_GPIO.lib
    ../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib W55FA92_FW050TFT_800x480.lib
target WQVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Font_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry 0
target VGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Font_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEMO_VGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry 0
target WVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Font_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry 0
