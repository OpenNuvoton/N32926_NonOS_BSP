# Keil uVision project VideoIn.uvproj, settings and files
target VIN_LIB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_VideoIn (library)
  AfterMake: VIN_LIB.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../../: VideoIn0.c VideoIn1.c W55FA92_VideoIn.c
