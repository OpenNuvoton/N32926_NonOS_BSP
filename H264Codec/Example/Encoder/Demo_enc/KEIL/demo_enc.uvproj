# Keil uVision project demo_enc.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo_enc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Lib;..\..\..\..\..\SYSLIB\Lib;..\..\..\..\..\SIC\Lib;..\..\..\..\..\NVTFAT\lib;..\..\..\..\..\GNAND\Lib;..\..\..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group 1
    ../../: h264e.c ratecontrol.c standalone.c wb_init.s
    ../../../../Lib/: H264Lib_Codec.lib
    ../../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../../../NVTFAT/lib/: W55FA92_nvtfat.lib
