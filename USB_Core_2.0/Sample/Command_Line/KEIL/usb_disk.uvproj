# Keil uVision project usb_disk.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: usb_disk
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\Inc;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../: Demo_CommandShell.c NVTFAT_ERROR.C standalone.c wb_init.s
    ../../../Lib/: W55FA92_UMAS.lib W55FA92_usbh.lib
    ../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../NVTFAT/lib/: W55FA92_nvtfat.lib
