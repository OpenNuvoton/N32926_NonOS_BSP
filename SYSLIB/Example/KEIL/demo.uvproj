# Keil uVision project demo.uvproj, settings and files
target DebugRel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Lib;..\..\..\GPIO\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group 1
    ../: demo.c demo_AIC.c demo_Cache.c demo_CLK.c demo_HUART.c demo_Timer.c demo_UART.c demo_wakeup.c standalone.c wb_init.s
    ../../Lib/: W55FA92_SYSLib.lib
    ../../../GPIO/Lib/: W55FA92_GPIO.lib
