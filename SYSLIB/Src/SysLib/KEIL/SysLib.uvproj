# Keil uVision project SysLib.uvproj, settings and files
target Syslib (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_syslib (library)
  AfterMake: Syslib.bat
  c flags: Optim=1 oTime=1 wLevel=2
  c include: ..\..\..\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: wb_aic.c wb_cache.c wb_config.c wb_mmu.c wb_power.c wb_timer.c wb_uart.c wb_dcache.s wb_sysctl.s wb_huart.c
target Syslib_FreeRTOS (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA92_syslib_freertos (library)
  AfterMake: Syslib_FreeRTOS.bat
  c flags: Optim=1 oTime=1 wLevel=2
  c define: __FreeRTOS__
  c include: ..\..\..\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
