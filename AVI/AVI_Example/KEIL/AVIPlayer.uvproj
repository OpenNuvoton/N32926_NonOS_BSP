# Keil uVision project AVIPlayer.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: AVIPlayer
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\SPU\Lib;..\..\..\JPEG\LIB;..\..\..\GNAND\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group 1
    ../: Demo_AVI.c standalone.c wb_init.s
    ../../Lib/: W55FA92_AVILib.lib IMA_ADPCM_Codec.lib MP3Lib.lib
    ../../../SYSLIB/Lib/: W55FA92_SYSLib.lib
    ../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../NVTFAT/lib/: W55FA92_NVTFAT.lib
    ../../../SPU/Lib/: W55FA92_SPU.lib
    ../../../JPEG/LIB/: W55FA92_JPEGLib.lib
    ../../../GNAND/Lib/: W55FA92_GNAND.lib
    ../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
