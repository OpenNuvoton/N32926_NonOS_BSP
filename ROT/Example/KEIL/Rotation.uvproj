# Keil uVision project Rotation.uvproj, settings and files
target ROT_LCM_QVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __LCM_320x240__
  c include: ..\..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib;..\..\..\SIC\Lib;..\..\..\VPOST\Lib;..\..\Example;..\..\..\GNAND\Lib;..\..\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib W55FA92_FW050TFT_800x480.lib
    ../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../Lib/: W55FA92_ROT.lib
    ../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../: wb_init.s ROT_demo.c ROT_main.c Smpl_VPOST.c standalone.c
target ROT_LCM_WVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __LCM_800x480__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
