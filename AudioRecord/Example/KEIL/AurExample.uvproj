# Keil uVision project AurExample.uvproj, settings and files
target DebugRel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: AurExample
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib;..\..\..\SIC\Lib;..\..\..\EDMA\lib;..\..\..\SPU\Lib;..\..\..\GNAND\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group 1
    ../: ADC_FileAccess.c AurEMDA.c AurExample.c EmuAudioRecord_Mono_AnalogMIC_AGC.c standalone.c wb_init.s
    ../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../EDMA/lib/: w55fa92_edma.lib
    ../../../SPU/Lib/: w55fa92_spu.lib
    ../../Lib/: W55FA92_AUR.lib
