# Keil uVision project demo.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\VPOST\Lib;..\..\..\..\SPI\Lib;..\..\..\..\VPOST\Example\ASIC
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group 1
    ../../: main.c Smpl_Pdma_SPI.c Smpl_Pdma_UART.c Smpl_Vdma.c standalone.c wb_init.s
    ../../../lib/: w55fa92_edma.lib
    ../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
    ../../../../SPI/Lib/: w55fa92_SPI.lib w55fa92_SPI_O2DN.lib
target DebugRel_O2DN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry 0
