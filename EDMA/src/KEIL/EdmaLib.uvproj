# Keil uVision project EdmaLib.uvproj, settings and files
target Release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_EDMA (library)
  AfterMake: Release.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: DrvEDMA.c w55fa92_edma.c
