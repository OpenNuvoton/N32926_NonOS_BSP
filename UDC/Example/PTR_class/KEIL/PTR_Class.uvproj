# Keil uVision project PTR_Class.uvproj, settings and files
target PTR_Class (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: PTR_Class
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group
    ../: main.c standalone.c wb_init.s PTR.c
  group Library Group
    ../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../Lib/: W55FA92_UDC.lib
