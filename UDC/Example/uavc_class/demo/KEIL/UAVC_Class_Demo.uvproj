# Keil uVision project UAVC_Class_Demo.uvproj, settings and files
target Vin_1stP_Format_Both (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: UAVC_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __1ST_PORT__
  c include: ..\..\I2CS;..\..\..\..\lib;..\..\..\..\..\SYSLIB\Lib;..\..\..\..\..\I2C\lib;..\..\..\..\..\GPIO\lib;..\..\..\..\..\JPEG\LIB;..\..\..\..\..\VideoIn\Lib;..\..\..\..\..\AudioRecord\Lib;..\..\..\..\..\EDMA\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../: adc.c demo.c Smpl_I2C.c Smpl_NT99050.c Smpl_NT99141.c Smpl_NT99160.c Smpl_OV7670.c Smpl_OV7725.c Smpl_OV9660.c standalone.c uvc_main.c wb_init.s
    ../../I2CS/: DrvI2C.c
    ../../../../lib/: w55fa92_UDC.lib w55fa92_UAVC.lib w55fa92_UAVC_YUV_Only.lib w55fa92_UAVC_MJPEG_Only.lib
    ../../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../../I2C/lib/: w55fa92_i2c.lib
    ../../../../../GPIO/lib/: w55fa92_gpio.lib
    ../../../../../JPEG/LIB/: w55fa92_jpeglib.lib
    ../../../../../VideoIn/Lib/: W55FA92_VideoIn.lib
    ../../../../../AudioRecord/Lib/: AudioRecord.lib
    ../../../../../EDMA/lib/: w55fa92_edma.lib
target Vin_1stP_Format_YUV_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: UAVC_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __1ST_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target Vin_1stP_Format_MJPEG_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: UAVC_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __1ST_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target Vin_2ndP_Format_Both (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: UAVC_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __2ND_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target Vin_2ndP_Format_YUV_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: UAVC_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __2ND_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target Vin_2ndP_Format_MJPEG_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: UAVC_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __2ND_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
