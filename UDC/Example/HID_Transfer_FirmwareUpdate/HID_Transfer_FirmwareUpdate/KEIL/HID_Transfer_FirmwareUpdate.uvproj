# Keil uVision project HID_Transfer_FirmwareUpdate.uvproj, settings and files
target HID_Transfer_FirmwareUpdate (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: HID_Transfer_FirmwareUpdate
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\..\AVI\Lib;..\..\..\..\..\VPOST\Lib;..\..\..\..\..\SYSLIB\Lib;..\..\..\..\..\SPU\Lib;..\..\..\..\..\SIC\Lib;..\..\..\..\..\NVTFAT\Lib;..\..\..\..\..\JPEG\Lib;..\..\..\..\..\GNAND\Lib;..\..\..\..\..\UDC\Lib;..\..\..\..\..\SPI\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group
    ../: standalone.c wb_init.s main.c jpegDec.c
  group Lib
    ../../../../../SYSLIB/Lib/: W55FA92_SYSLib.lib
    ../../../../../VPOST/Lib/: W55FA92_VPOST.lib
    ../../../../../JPEG/Lib/: W55FA92_JPEGLib.lib
    ../../../../../UDC/Lib/: W55FA92_UDC.lib
  group HID
    ../: HID.c spi.c spiflash.c SpiRead.c
