# Keil uVision project mass_storage.uvproj, settings and files
target NAND0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: MSC_NAND0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\SIC\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\GNAND\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../: main.c standalone.c wb_init.s
    ../../../lib/: w55fa92_MSC_RAM.lib w55fa92_MSC_NAND_SD.lib w55fa92_MSC_NAND.lib w55fa92_MSC_SD.lib w55fa92_UDC.lib w55fa92_MSC_SPI.lib
    ../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../../../GNAND/Lib/: w55fa92_GNAND.lib
    ../../../../SPI/Lib/: w55fa92_SPI.lib
target NAND&SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MSC_NAND&SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target SD0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MSC_SD0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_ONLY__ __SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target SD0&1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MSC_SD0&1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_ONLY__ __SD__ __TWO_SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MSC_RamDiskOnly
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_ONLY__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MSC_SPI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\SIC\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\GNAND\Lib;..\..\..\..\SPI\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
