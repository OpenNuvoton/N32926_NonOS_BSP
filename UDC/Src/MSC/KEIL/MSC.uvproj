# Keil uVision project MSC.uvproj, settings and files
target SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_MSC_SD (library)
  AfterMake: SD.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_SD
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\GNAND\Lib;..\..\..\..\SIC\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../MSC/: mscd.c
target NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA92_MSC_NAND (library)
  AfterMake: NAND.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_SM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target NAND&SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA92_MSC_NAND_SD (library)
  AfterMake: "NAND&SD.bat"
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target RAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA92_MSC_RAM (library)
  AfterMake: RAM.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA92_MSC_All (library)
  AfterMake: All.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_SD TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA92_MSC_SPI (library)
  AfterMake: SPI.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_SPI
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\GNAND\Lib;..\..\..\..\SIC\Lib;..\..\..\..\SPI\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
