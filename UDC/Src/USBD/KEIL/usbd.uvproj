# Keil uVision project usbd.uvproj, settings and files
target Standard mode (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_UDC (library)
  AfterMake: Standard mode.bat
  c flags: Optim=1 wLevel=2
  c define: __USBD_STANDARD_MODE__
  c include: ..\..\..\lib;..\..\..\..\NVTFAT\lib;..\..\..\..\GNAND\Lib;..\..\..\..\SIC\Lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../USBD/: usbd.c
target Full speed mode (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA92_UDC_Fullspeed (library)
  AfterMake: Full speed mode.bat
  c flags: Optim=1 wLevel=2
  c define: __USBD_FULL_SPEED_MODE__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target High speed mode (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA92_UDC_Highspeed (library)
  AfterMake: High speed mode.bat
  c flags: Optim=1 wLevel=2
  c define: __USBD_HIGH_SPEED_MODE__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
