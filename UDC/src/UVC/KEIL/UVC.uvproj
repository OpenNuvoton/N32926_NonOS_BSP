# Keil uVision project UVC.uvproj, settings and files
target FORMAT_BOTH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_UVC (library)
  AfterMake: FORMAT_BOTH.bat
  c flags: Optim=1 wLevel=2
  c define: UVC_FORMAT_BOTH
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\GNAND\Lib;..\..\..\..\SIC\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../UVC/: video_class.c
target FORMAT_YUV_ONLY (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA92_UVC_YUV_Only (library)
  AfterMake: FORMAT_YUV_ONLY.bat
  c flags: Optim=1 wLevel=2
  c define: UVC_FORMAT_YUV
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target FORMAT_MJPEG_ONLY (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA92_UVC_MJPEG_Only (library)
  AfterMake: FORMAT_MJPEG_ONLY.bat
  c flags: Optim=1 wLevel=2
  c define: UVC_FORMAT_MJPEG
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
