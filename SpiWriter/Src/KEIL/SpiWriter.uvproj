# Keil uVision project SpiWriter.uvproj, settings and files
target N32926_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SpiWriter(S)_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_ __Security__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\GPIO\lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib;..\..\..\Font\Lib;..\..\..\GNAND\Lib;..\..\..\SPI\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../: DrawFont.c playsound.c ProcessIni.c ProcessOptionalIni.c spiflash.c standalone.c Writer.c wb_init.s Rootkey.c
    ../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../../GPIO/lib/: w55fa92_gpio.lib
    ../../../SPU/Lib/: w55fa92_spu.lib
    ../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
    ../../../SPI/Lib/: w55fa92_Secureic.lib
    ../../../Font/Lib/: W55FA92_Font_QVGA.lib
target N32926_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiWriter(S)
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __Security__ __NoLCM__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
