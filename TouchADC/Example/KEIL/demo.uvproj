# Keil uVision project demo.uvproj, settings and files
target DebugRel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../: demo.c demo_Integration.c demo_Keypad.c demo_Touchpanel.c demo_Voltagedetection.c EmuTouch_BitToggle.c EmuTouch_Reset.c standalone.c wb_init.s
    ../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../Lib/: W55FA92_ADC.lib
