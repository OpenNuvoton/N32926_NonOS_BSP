# Keil uVision project TouchADCLib.uvproj, settings and files
target LibTouch_DEV (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_ADC (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\Lib
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../: DrvTouch.c KeyDEV.c KeyEVB.c
