# Keil uVision project LibTouch.uvproj, settings and files
target LibTouch_EVB (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa92_ts_adc (library)
  AfterMake: LibTouch_EVB.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: DrvTouch.c KeyDEV.c KeyEVB.c
target LibTouch_DEV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa92_ts_adc (library)
  AfterMake: LibTouch_DEV.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
