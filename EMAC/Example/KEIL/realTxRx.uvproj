# Keil uVision project realTxRx.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: realTxRx
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _W55FA92_ CACHE_ON
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib
  asm define: _DRAM_SIZE_32MB_
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group 1
    ../: mac.c standalone.c wb_init.s
    ../../Lib/: EMACLib.lib
    ../../../SYSLIB/Lib/: W55FA92_syslib.lib
