# Keil uVision project SDLoader.uvproj, settings and files
target SDLoader_not_set_clock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32926_SDLoader_not_set_clock_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_NOT_SET__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../: Depop.c sd.c SdLoader.c standalone.c wb_aic.c wb_cache.c wb_config.c wb_mmu.c wb_power.c wb_timer.c wb_uart.c heap.s stack.s vectors.s wb_dcache.s wb_init.s wb_sysctl.s
target SDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32926_SDLoader_192MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
target SDLoader_240MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32926_SDLoader_240MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_240__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
