# Keil uVision project H264Lib.uvproj, settings and files
target Disable_reorder (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: H264Lib_Codec (library)
  AfterMake: Disable_reorder.bat
  c flags: Optim=1 wLevel=2
  c define: _DISABLE_REORDER_ _USE_INT_ _RESET_IP_
  c include: ..\..\..\Lib;..\..\..\Src;..\..\Decoder;..\..\Encoder;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: favc_module.c h264_common.c Lib_wrapper.c nv_mem.c
    ../../Decoder/: AVCdec.c decoder.c favc_dec_opt.c h264_funct.c
    ../../Encoder/: bs.c common.c encoder.c favc_enc_opt.c memory.c sequence.c slice.c
