# Keil uVision project demo_dec.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo_dec
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Lib;..\..\..\..\..\SYSLIB\Lib;..\..\..\..\..\SIC\Lib;..\..\..\..\..\NVTFAT\lib;..\..\..\..\..\VPOST\Lib;..\..\..\..\..\VPE\Lib;..\..\..\..\..\GNAND\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group 1
    ../../: h264d.c standalone.c VPE_func.c wb_init.s
    ../../../../Lib/: H264Lib_Codec.lib
    ../../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
    ../../../../../VPE/Lib/: W55FA92_VPE.lib
