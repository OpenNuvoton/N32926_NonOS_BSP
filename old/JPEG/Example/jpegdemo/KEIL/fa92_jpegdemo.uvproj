# Keil uVision project fa92_jpegdemo.uvproj, settings and files
target JPEG_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: fa92_jpegdemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\VPOST\Lib;..\..\..\..\SIC\Lib;..\..\..\..\GNAND\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group 1
    ../: standalone.c wb_init.s
    ../../: common.c jpegDec.c jpegEnc.c main.c
    ../../../LIB/: w55fa92_jpeglib.lib
    ../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
    ../../../../SIC/Lib/: W55FA92_SIC.lib
