# Keil uVision project EMACLib.uvproj, settings and files
target EVB_Board (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: EMACLib (library)
  AfterMake: EVB_Board.bat
  c flags: Optim=1 wLevel=2
  c define: _W55FA92_
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: maclib.c
target DEV_Board (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: EMACLib (library)
  AfterMake: DEV_Board.bat
  c flags: Optim=1 wLevel=2
  c define: _W55FA92_ PHY_RTL8201F
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
