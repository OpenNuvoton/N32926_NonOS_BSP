# Keil uVision project W55FA92_demo.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\Inc;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\..\..\Inc\MASSCLS
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../: main.c usb_keyboard.c W99683.c wb_init.s
    ../../../Lib/: W55FA92_UMAS.lib W55FA92_usbh.lib
    ../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../NVTFAT/lib/: W55FA92_nvtfat.lib
