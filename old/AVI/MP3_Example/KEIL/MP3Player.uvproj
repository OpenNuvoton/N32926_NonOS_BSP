# Keil uVision project MP3Player.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: MP3Player
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\JPEG\LIB;..\..\..\GNAND\Lib;..\..\..\SPU\Lib;..\..\..\AudioRecord\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group 1
    ../: Demo_MP3.c standalone.c wb_init.s
    ../../Lib/: AviLib_320x240.lib ima_adpcm_codec.lib mp3lib.lib
    ../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../../JPEG/LIB/: w55fa92_jpeglib.lib
    ../../../GNAND/Lib/: w55fa92_GNAND.lib
    ../../../SPU/Lib/: w55fa92_spu.lib
    ../../../AudioRecord/Lib/: AudioRecord.lib
    ../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
