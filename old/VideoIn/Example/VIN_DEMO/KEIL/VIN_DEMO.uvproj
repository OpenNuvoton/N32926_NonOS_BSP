# Keil uVision project VIN_DEMO.uvproj, settings and files
target PC2M01-2D01-GP-QVGA-Port1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: VIN_DEMO
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __LCM_320x240__ __DEV__ __1ST_PORT__
  c include: ..\..\..\Lib;..\..\I2CS;..\..\..\..\SYSLIB\Lib;..\..\..\..\VPOST\Lib;..\..\..\..\GPIO\lib;..\..\..\..\JPEG\LIB;..\..\..\..\NVTFAT\lib;..\..\..\..\SIC\Lib;..\..\..\..\GNAND\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../: demo.c FileWrite.c jpegEnc.c Smpl_HM1375.c Smpl_I2C.c Smpl_NT99050.c Smpl_NT99141.c Smpl_NT99160.c Smpl_NT99252.c Smpl_NT99340.c Smpl_OV7670.c Smpl_OV7725.c Smpl_OV9660.c Smpl_VPOST.c Smpl_WT8861.c Smpl_GC0308.c Smpl_SA71113.c Smpl_SP1628.c Smpl_TW9912.c Smpl_TW9900.c Smpl_GM7150.c Smpl_NT99142.c Smpl_OV10633.c Smpl_SC1046.c Smpl_TVP5150.c Smpl_HM1246.c Smpl_HM2056.c
    ../../Startup/: standalone.c wb_init.s
    ../../../Lib/: W55FA92_VideoIn.lib
    ../../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
    ../../../../GPIO/lib/: w55fa92_gpio.lib
    ../../../../JPEG/LIB/: w55fa92_jpeglib.lib
    ../../../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../../../SIC/Lib/: W55FA92_SIC.lib
    ../../I2CS/: DrvI2C.c
target PC2M01-2D01-GP-QVGA-Port2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: VIN_DEMO
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __LCM_320x240__ __DEV__ __2ND_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
