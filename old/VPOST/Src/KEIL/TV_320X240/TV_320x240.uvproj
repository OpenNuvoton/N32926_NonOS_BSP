# Keil uVision project TV_320x240.uvproj, settings and files
target W55FA92_TV_320x240 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA92_TV_320x240 (library)
  AfterMake: W55FA92_TV_320x240.bat
  c flags: Optim=1 wLevel=2
  c define: __HAVE_TVOUT_320x240__
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: W55FA92_VPOST.C W55FA92_VPOST_Driver.c W55FA92_VPOST_TVOUT_QVGA_320x240.c
