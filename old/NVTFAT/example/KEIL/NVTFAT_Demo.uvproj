# Keil uVision project NVTFAT_Demo.uvproj, settings and files
target FAT_NAND_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ENABLE_GNAND
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\GNAND\Lib;..\..\..\SIC\Lib;..\..\..\SDIO\Lib;..\..\..\USB_Core_2.0\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../: Demo_CommandShell.c NVTFAT_ERROR.C RAMDiskDriver.c standalone.c wb_init.s
    ../../lib/: W55FA92_nvtfat.lib
    ../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../GNAND/Lib/: w55fa92_GNAND.lib
    ../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../SDIO/Lib/: W55FA92_SDIO.lib
    ../../../USB_Core_2.0/Lib/: W55FA92_usbh.lib W55FA92_UMAS.lib
target FAT_SD_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ENABLE_SD ENABLE_SD_ONE_PART
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target FAT_SD_TWO_PART (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ENABLE_SD ENABLE_SD_TWO_PART
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target FAT_SD_FOUR_PART (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ENABLE_SD ENABLE_SD_FOUR_PART
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target FAT_USBH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ENABLE_USB_HOST
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\GNAND\Lib;..\..\..\SIC\Lib;..\..\..\SDIO\Lib;..\..\..\USB_Core_2.0\Lib;..\..\..\USB_Core_2.0\Inc
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target FAT_RAM_SD_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ENABLE_RAM ENABLE_SD ENABLE_SD_ONE_PART
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
target FAT_SDIO1_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ENABLE_SDIO_1 ENABLE_SD_ONE_PART
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
