# Keil uVision project dev_Secureic.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa92_Secureic (library)
  AfterMake: DebugRel.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: Gneiss.c Secureic.c
