# Keil uVision project NVT_Loader.uvproj, settings and files
target SD_GIANTPLUS_QVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVT_SDU0_Fast_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __LCM_320x240__ __ENABLE_SD_CARD_0__ __NVT_DEV_DEMO_SD__
  c include: ..\inc;..\..\SYSLIB\Lib;..\..\AudioRecord\Lib;..\..\TouchADC\Lib;..\..\AVI\Lib;..\..\GPIO\lib;..\..\NVTFAT\lib;..\..\JPEG\LIB;..\..\GNAND\Lib;..\..\SIC\Lib;..\..\SPU\Lib;..\..\UDC\lib;..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../src/: board_gaintplus_demo.c NVT_avi.c NVT_boot_from_nand.c NVT_boot_from_sd.c NVT_Keypad.c NVT_main.c NVT_mass.c NVT_Voltagedetection.c NVT_vpost.c standalone.c heap.s stack.s vectors.s wb_init.s
    ../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../AVI/Lib/: AviLib_320x240.lib ima_adpcm_codec.lib mp3lib.lib
    ../../GPIO/lib/: w55fa92_gpio.lib
    ../../NVTFAT/lib/: W55FA92_nvtfat.lib
    ../../JPEG/LIB/: w55fa92_jpeglib.lib
    ../../GNAND/Lib/: w55fa92_GNAND.lib
    ../../SIC/Lib/: W55FA92_SIC.lib
    ../../SPU/Lib/: w55fa92_spu.lib
    ../../UDC/lib/: w55fa92_MSC_NAND.lib w55fa92_MSC_SD.lib w55fa92_UDC.lib
    ../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
    ../../TOUCHADC/Lib/: W55FA92_ADC.lib
target NAND_GAINTPLUS_QVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_Fast_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __LCM_320x240__ __ENABLE_NAND_0__ __NVT_DEV_DEMO_NAND__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat.scf
  link misc: --entry Reset_Go
