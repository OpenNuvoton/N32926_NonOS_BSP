# Keil uVision project fa92_PWMdemo.uvproj, settings and files
target SingleTask (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: fa92_PWMdemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../: standalone.c wb_init.s
    ../../: main.c
    ../../../LIB/: w55fa92_PWMlib.lib
    ../../../../SYSLIB/Lib/: W55FA92_syslib.lib
