# Keil uVision project gpio.uvproj, settings and files
target Release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: gpio
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Source Group 1
    ../: gpio.c standalone.c wb_init.s
    ../../Lib/: W55FA92_GPIO.lib
    ../../../SYSLIB/Lib/: W55FA92_SYSLib.lib
