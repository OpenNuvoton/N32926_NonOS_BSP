# Keil uVision project NVTFAT_FreeRTOS.uvproj, settings and files
target NVTFAT_NAND (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: RTOSDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Startup;..\..\..\Source\portable\RVDS\ARM9_N329x;..\..\..\Source\include;..\..\Common\include;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\Lib;..\..\..\..\GNAND\Lib;..\..\..\..\SIC\Lib
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry 0
  group Startup
    ../Startup/: wb_init.s standalone.c multithread.c main.c
  group Lib
    ../../../../SYSLIB/Lib/: W55FA92_syslib_freertos.lib
    ../../../../NVTFAT/Lib/: W55FA92_NVTFAT_FreeRTOS.lib
    ../../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../../GNAND/Lib/: W55FA92_GNAND.lib
  group FreeRTOS
    ../../../Source/: tasks.c list.c queue.c
    ../../../Source/portable/MemMang/: heap_2.c
    ../../../Source/portable/RVDS/ARM9_N329x/: port.c portASM.s
target NVTFAT_SD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: RTOSDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STORAGE_SD
  c include: as above
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32926\N32926.sct
  link misc: --entry 0
