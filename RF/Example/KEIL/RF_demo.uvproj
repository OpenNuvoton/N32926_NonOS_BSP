# Keil uVision project RF_demo.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: RF_demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\EDMA\lib;..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\GNAND\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32926\N32926.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../: RF_main.c standalone.c wb_init.s
    ../../Lib/: W55FA92_RF.lib
    ../../../SYSLIB/Lib/: W55FA92_syslib.lib
    ../../../EDMA/lib/: w55fa92_edma.lib
    ../../../SIC/Lib/: W55FA92_SIC.lib
    ../../../NVTFAT/lib/: W55FA92_nvtfat.lib
