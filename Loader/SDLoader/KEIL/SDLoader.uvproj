# Keil uVision project SDLoader.uvproj, settings and files
target SDLoader_not_set_clock (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32926_SDLoader_not_set_clock_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __UPLL_NOT_SET__ __UVISION_VERSION
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../: Depop.c sd.c SdLoader.c standalone.c wb_aic.c wb_cache.c wb_config.c wb_mmu.c wb_power.c wb_timer.c wb_uart.c heap.s stack.s vectors.s wb_init.s
target SDLoader_192MHz (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32926_SDLoader_192MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __UPLL_192__ __UVISION_VERSION
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
target SDLoader_240MHz (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32926_SDLoader_240MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __UPLL_240__ __UVISION_VERSION
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
