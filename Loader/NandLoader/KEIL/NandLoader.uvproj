# Keil uVision project NandLoader.uvproj, settings and files
target NANDLoader_not_set_clock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32926_NANDLoader_not_set_clock_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_NOT_SET__ __UVISION_VERSION
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../: Depop.c NandDrv.c NandLoader.c standalone.c wb_aic.c wb_cache.c wb_config.c wb_mmu.c wb_power.c wb_timer.c wb_uart.c heap.s stack.s vectors.s wb_init.s
  group User_Define_Func
    ../user_define/: user_define_func.c
    ../../../VPOST/Lib/: W55FA92_GIANTPLUS_GPM1006D.lib
target NANDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32926_NANDLoader_192MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_192__ __UVISION_VERSION
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
target NANDLoader_240MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32926_NANDLoader_240MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_240__ __UVISION_VERSION
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
target NANDLoader_240MHz_Logo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32926_NANDLoader_240MHz_Fast_Logo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_240__ __USER_DEFINE_FUNC __UVISION_VERSION
  c include: ..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\VPOST\Lib; ..
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
